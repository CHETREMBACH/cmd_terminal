# IAR project MODULE_STM32F103.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103C8 ST STM32F103C8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_MD; DBG_UART_ENABLE=1
  ICCARM.CCIncludePath2: ..\..\Libraries\CMSIS\Include; ..\..\Libraries\CMSIS\Device\ST\STM32F10x\Include; ..\..\Libraries\CMSIS\Device\ST\STM32F10x\Source\Templates\iar; ..\..\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\Config; ..\Include; ..\..\Utilities\hal_board; ..\..\Utilities\uart_dbg; ..\..\Utilities\cmd_hndlr
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: MODULE_STM32F103.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ..\..\Project\Linker\stm32f103x6.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Libraries/CMSIS/Device/ST/STM32F10x/Include
    ../../Libraries/CMSIS/Device/ST/STM32F10x/Include/: stm32f10x.h system_stm32f10x.h
  group Libraries/CMSIS/Device/ST/STM32F10x/Source/Templates
    ../../Libraries/CMSIS/Device/ST/STM32F10x/Source/Templates/: system_stm32f10x.c
  group Libraries/CMSIS/Device/ST/STM32F10x/Source/Templates/iar
    ../../Libraries/CMSIS/Device/ST/STM32F10x/Source/Templates/iar/: startup_stm32f10x_md.s
  group Libraries/STM32F10x_StdPeriph_Driver/inc
    ../../Libraries/STM32F10x_StdPeriph_Driver/inc/: misc.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_cec.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_wwdg.h
  group Libraries/STM32F10x_StdPeriph_Driver/src
    ../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Progect/Config
    ../Config/: stm32f10x_conf.h
  group Progect/Include
    ../Include/: main.h stm32_it.h
  group Progect/Linker
    ../Linker/: stm32f103x6.icf
  group Progect/Source
    ../Source/: main.c stm32_it.c
  group Utilities/cmd_hndlr
    ../../Utilities/cmd_hndlr/: cmd_hdl.c cmd_hdl.h cmd_hlp.c cmd_hlp.h cmd_process.c cmd_process.h cmd_tabl.c cmd_tabl.h
  group Utilities/hal_board
    ../../Utilities/hal_board/: board.c board.h
  group Utilities/uart_dbg
    ../../Utilities/uart_dbg/: printf_dbg.c printf_dbg.h uart_dbg.c uart_dbg.h
